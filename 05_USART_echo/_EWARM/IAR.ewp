# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042K6 ST STM32F042K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F042x6
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Device; ..\CMSIS\Include; ..\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: IAR.bin
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: stm32f042x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group _EWARM
    ./: startup_stm32f042x6.s stm32f042x6_flash.icf
  group CMSIS/Device
    ../CMSIS/Device/: stm32f042x6.h stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group CMSIS/Include
    ../CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm0.h
  group user/inc
    ../user/inc/: RCC.h
  group user/src
    ../user/src/: RCC.c
